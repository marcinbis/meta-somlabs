FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
	file://0001-Whitelist-kernel-v4.20.12-as-we-explicite-patch-it.patch \
"
