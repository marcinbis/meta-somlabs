PACKAGECONFIG_append = " no-opengl accessibility fontconfig linuxfb tslib libinput"
PACKAGECONFIG_remove = "examples tests gbm eglfs gl gles2 kms"
