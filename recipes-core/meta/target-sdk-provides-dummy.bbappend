#Do not install the following recipes to SDK (avoid conflicts, atc.)
DUMMYPROVIDES_append = " \
	murata-fwmac-fw \
	murata-fwmac-fw-dev \
	linux-firmware-bcm43430 \
	linux-firmware-bcm43430-dev \
"
